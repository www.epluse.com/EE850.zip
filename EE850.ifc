Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
Time: Thu Aug 13 06:58:42 2020
Author: at3107
Written by: PTC Creo 1.0
Made in: PTC

# IfcProject, Default Project
LongName: Project Status; Phase: Project Status

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 mm

# IfcBuildingElementProxy: Part, EE850
In: Default Storey
PTC_Identity Data - DEVICENAME: CO2, RH and T duct mount sensor; MEASURAND1: CO2; Measuring range 0...2000 / 5000 / 10000 ppm; OUTPUT1: Analogue voltage / current; 0-5 V / 0-10 V / 4-20 mA; OUTPUT2: Digital interface; RS485 with Modbus RTU or BACnet MS/TP; SUPPLY: 24 V AC ±20 % / 15-35 V DC; ENCLOSUREMATERIAL: Polycarbonate / UL94V-0 approved; ENCLOSUREDIMENSIONS: WxHxD = 80.6x101x46 mm (3.17x3.98x1.81"); ENCLOSUREDESIGNSTANDARD: Cover: light grey RAL7035; housing: E+E green RAL6018; MEASURAND2: Temperature; Measuring range -20...60 °C (-4...140 °F); MEASURAND3: Relative humidity; Measuring range 0...95 % RH; OUTPUT3: Passive T-Sensor; VOLUME: 357199; SURFACE_AREA: 38916.6; MASS: 357199; DENSITY: 1; CENTRE_OF_GRAVITY_X: 13.2593; CENTRE_OF_GRAVITY_Y: -0.4337; CENTRE_OF_GRAVITY_Z: 1.2465
